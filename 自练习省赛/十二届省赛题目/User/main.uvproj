# Keil uVision project main.uvproj, settings and files
target main (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drive
  group user
    ./: STARTUP.A51 main.c
  group driver
    ../Drive/: key.c smg.c onewire.c
