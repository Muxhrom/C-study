# Keil uVision project test6.uvproj, settings and files
target test6 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test6 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\driver
  group user
    ./: STARTUP.A51 main.c
  group driver
    ../driver/: Key.c Seg.c
