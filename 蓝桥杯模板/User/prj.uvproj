# Keil uVision project prj.uvproj, settings and files
target cys (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: prj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Driver
  group User
    ./: main.c main.h
  group Driver
    ../Driver/: sys.c sys.h key.c key.h seg.c seg.h led.c led.h ds1302.c ds1302.h onewire.c onewire.h iic.c iic.h Uart.c Uart.h ultra.c ultra.h
